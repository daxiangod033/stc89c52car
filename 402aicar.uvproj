# Keil uVision project 402aicar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 402aicar +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./src/: bt.c bt.h bz.c bz.h main.c motor.c motor.h timer.c timer.h xj.c xj.h
